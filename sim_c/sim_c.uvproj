# Keil uVision project sim_c.uvproj, settings and files
target Firmware (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: sim_c +hex
  AfterMake: ../hex2bin -p 00 #H
  c flags: Optimize=9
  group Source
    ./: STARTUP.A51 globals.h i2c.c i2c.h iso7816.c iso7816.h t1.c t1.h SIM.C timer.c timer.h uart.c uart.h Common.h Function_Define.h N76E003.h SFR_Macro.h
