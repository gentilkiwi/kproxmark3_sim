# Keil uVision project sim011.uvproj, settings and files
target Firmware (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: sim011 +hex
  AfterMake: ../hex2bin -p 00 #H
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: sim011.asm
